# Keil uVision project STM32F7.uvprojx, settings and files
target STemWin (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F7 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ..\User;..\..\00-Libraries;..\..\00-Drivers\CMSIS\Include;..\..\00-Drivers\CMSIS\Device\Include;..\..\00-Drivers\STM32F7xx_HAL_Driver\Inc;..\..\00-STemWin\Fonts;..\..\00-STemWin\inc;..\..\00-Drivers\BSP\STM32746G-Discovery
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f7xx_it.c
  group Startup
    ../../00-Drivers/CMSIS/Device/Source/: system_stm32f7xx.c startup_stm32f746xx.s
  group Library
    ../../00-Libraries/: stm32f7_system.c stm32f7_led.c stm32f7_delay.c
  group HAL_Driver
    ../../00-Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma.c stm32f7xx_hal_i2c.c stm32f7xx_hal_ltdc.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_uart.c
  group BSP
    ../../00-Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_sdram.c
  group STemWin_Lib
    $TC_ROOT$/../../Users/dauden/Desktop/stm32f7/00-STemWin/Lib/: STemWin528_CM7_Keil.lib
  group STemWin_Config
    ../../00-STemWin/OS/: GUI_X.c
    ../User/: GUIConf.c LCDConf.c
