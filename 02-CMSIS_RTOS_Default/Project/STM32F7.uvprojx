# Keil uVision project STM32F7.uvprojx, settings and files
target CMSIS_RTOS (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F7 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ..\User;..\..\00-Libraries;..\..\00-Drivers\CMSIS\Include;..\..\00-Drivers\CMSIS\Device\Include;..\..\00-Drivers\STM32F7xx_HAL_Driver\Inc;..\..\00-CMSIS_RTOS\CMSIS_RTOS;..\..\00-CMSIS_RTOS\include;..\..\00-CMSIS_RTOS\portable\RVDS\ARM_CM7\r0p1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f7xx_it.c
  group Startup
    ../../00-Drivers/CMSIS/Device/Source/: system_stm32f7xx.c startup_stm32f746xx.s
  group Library
    ../../00-Libraries/: stm32f7_system.c stm32f7_led.c stm32f7_delay.c
  group HAL_Driver
    ../../00-Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c
  group CMSIS_RTOS
    ../../00-CMSIS_RTOS/CMSIS_RTOS/: cmsis_os.c
  group Free_RTOS
    ../../00-CMSIS_RTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group portable
    ../../00-CMSIS_RTOS/portable/MemMang/: heap_4.c
    ../../00-CMSIS_RTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
